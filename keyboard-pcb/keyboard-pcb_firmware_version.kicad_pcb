# Repository Allorx/PCB-Design

File README.md:

# PCB-Design
Prototype Keyboard design project "Orions Hands V0.1"

Contains a custom mechanical keyboard PCB design [keyboard-pcb](keyboard-pcb) and firmware [keyboard-code](keyboard-code).

## Key Features:
* NKRO support over USB using a RP Pico and Rust
* Custom layout with pushable rotary encoder consumer controls over USB (vol +/-, pause, next/prev track)
* I2C display (SSD1309) with embedded-graphics
* Multicore for efficiency/speed (core0: keyboard/usb hid, core1: display/other)

## Tests:
Check [keyboard-code](keyboard-code). There seems to be a hardware issue with this design causing ghosting after extensive use...

## To Improve:
* Use pull up resistors rather than relying on pi pico internal pull ups
* Grounding fill (and thicker traces?)

## IMPORTANT!
1) The space on the front side of the pcb on the right is reserved for a small I2C display.
   
2) The rp pico usb micro-b connector is only slightly accessible after soldering - this is because the intention is to extend the connector, using usb-c or an alternative 4 wire connector, away from the controller. The connector can then be case mounted for more freedom of positioning. This extension of the connector can be done in 2 ways:
    * slightly more fiddly way (my solution), plugging in a stripped usb micro-b cable into the controller -> the other end can then be connected to a usb-c breakout board or alternative 4 pin connector (the rotary encoders clips may have to be clipped to give some more room). The wires end up on the bottom of keyboard.
    * solder a connection for usb-c on the back of the rp pico (care not to break solder pads) -> demonstrated here: [usb-c mod for rp pico](https://www.reddit.com/r/raspberry_pi/comments/m8p2ed/usb_type_c_mod_for_pico/). The wires will end up on the top of the keyboard. The PCB has a cutout to make these pads easily accessible. If you would like to put the connector on the back of the keyboard using this method it may be convenient to have a hole in the pcb for connector wires to go to the back rather than over the side of the pcb.

3) Some keycaps are not standard sizes: caps lock is stepped; backspace and enter keys are 0.5u shorter than standard; and '#/~' keys are 0.25u shorter than standard - these decisions were made to make the keyboard cleaner/more compact and so that the space bar is the only key that needs to have a stabiliser! The disadvantage is the keys can be more difficult to buy/re-use. Some keys have also been removed to keep most commonly used keys - feel free to change it!

## Inspiration and key resources:
* [The Switch Matrix - PCB Design for Mechanical Keyboards](https://www.youtube.com/watch?v=vLGklanzQIc) - important for understanding how a keyboard matrix works
* [Keyboard layout editor](http://www.keyboard-layout-editor.com/) - useful for figuring out your layout
* [Keyboard PCB Design Guide](https://wiki.ai03.com/books/pcb-design/page/pcb-guide-part-1---preparations) - good for general guidance and set up for making keyboard PCB's in KiCAD - note: this is for a macropad, not for a key matrix; this guide uses a bare bones mcu not a development board; the latest version of KiCAD is best to use contrary to the guide (it has improved a lot) -> despite the issues it is very good for general understanding, required schematics/footprints for keyboards and tips/tricks in KiCAD 
* [KiCAD RP Pico](https://github.com/ncarandini/KiCad-RP-Pico) - a great resource for the schematic, footprints and 3D model of the rp pico for use in KiCAD
* [usbd-human-interface-device (rp pico Rust crate)](https://github.com/dlkj/usbd-human-interface-device) - great crate for usb hid! Much (the core) of the firmware is based on this crate and examples within
* Ben Eater's youtube videos on keyboards - someone has put together a playlist of these: [Ben Eater keyboard interface (playlist)](https://youtube.com/playlist?list=PLInUV34wyeCZ7whCxtxIWtcLeoI49szQo)
* For better understanding of how it comes together I would also recommend reading: some documentation on the rp pico; about usb hid protocols; about mechanical switch debounce; about n-key roll over (NKRO) for usb hid keyboards; about pushable rotary encoders; about the Rust language; how spi/i2c works for adding external devices (Ben Eater also has some videos on this); about multicore on rp pico in Rust

## KiCad design keyboard-pcb/keyboard-pcb_firmware_version.kicad_pcb

File keyboard-pcb/readme.md:

# keyboard-pcb

Contains files for the keyboard pcb made in KiCad.
* "keyboard-pcb_firmware_version.kicad_pro" matches the firmware.
* "keyboard-pcb.kicad_pro" is more efficient (need to reverse scanning in firmware).

Parts:
ALT1, ALT2: MX-NoLED; SW_Cherry_MX_1.25u_PCB
BKSP1: MX-NoLED; SW_Cherry_MX_1.50u_PCB
CAP1: MX-NoLED; SW_Cherry_MX_1.25u_PCB
CTRL1: MX-NoLED; SW_Cherry_MX_1.25u_PCB
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65: D_Small; D_SOD-123
DEL1: MX-NoLED; SW_Cherry_MX_1.00u_PCB
DWN1: MX-NoLED; SW_Cherry_MX_1.00u_PCB
ENT1: MX-NoLED; SW_Cherry_MX_1.75u_PCB
FNC1: MX-NoLED; SW_Cherry_MX_1.25u_PCB
LFT1: MX-NoLED; SW_Cherry_MX_1.00u_PCB
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX30, MX31, MX32, MX33, MX34, MX35, MX36, MX37, MX38, MX39, MX40, MX41, MX42, MX43, MX44, MX45, MX46, MX47: MX-NoLED; SW_Cherry_MX_1.00u_PCB
MX48: MX-NoLED; SW_Cherry_MX_1.25u_PCB
RHT1: MX-NoLED; SW_Cherry_MX_1.00u_PCB
SHFT1: MX-NoLED; SW_Cherry_MX_1.25u_PCB
SPC1: MX-NoLED; SW_Cherry_MX_6.25u_PCB
SUP1: MX-NoLED; SW_Cherry_MX_1.25u_PCB
SW1: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
TAB1: MX-NoLED; SW_Cherry_MX_1.50u_PCB
U1: Pico; RPi_Pico_SMD_TH
UP1: MX-NoLED; SW_Cherry_MX_1.00u_PCB

Connections:
CLK: SW1.A, U1.1 (GPIO0)
COL_0: CAP1.1 (COL), CTRL1.1 (COL), MX1.1 (COL), SHFT1.1 (COL), TAB1.1 (COL), U1.17 (GPIO13)
COL_1: MX2.1 (COL), MX3.1 (COL), MX4.1 (COL), MX5.1 (COL), SUP1.1 (COL), U1.19 (GPIO14)
COL_2: ALT1.1 (COL), MX6.1 (COL), MX7.1 (COL), MX8.1 (COL), MX9.1 (COL), U1.20 (GPIO15)
COL_3: MX10.1 (COL), MX11.1 (COL), MX12.1 (COL), MX13.1 (COL), U1.16 (GPIO12)
COL_4: MX14.1 (COL), MX15.1 (COL), MX16.1 (COL), MX17.1 (COL), U1.15 (GPIO11)
COL_5: MX18.1 (COL), MX19.1 (COL), MX20.1 (COL), MX21.1 (COL), U1.14 (GPIO10)
COL_6: MX22.1 (COL), MX23.1 (COL), MX24.1 (COL), MX25.1 (COL), SPC1.1 (COL), U1.12 (GPIO9)
COL_7: MX26.1 (COL), MX27.1 (COL), MX28.1 (COL), MX29.1 (COL), U1.11 (GPIO8)
COL_8: MX30.1 (COL), MX31.1 (COL), MX32.1 (COL), MX33.1 (COL), U1.4 (GPIO2)
COL_9: ALT2.1 (COL), MX34.1 (COL), MX35.1 (COL), MX36.1 (COL), MX37.1 (COL), U1.5 (GPIO3)
COL_10: FNC1.1 (COL), MX38.1 (COL), MX39.1 (COL), MX40.1 (COL), MX41.1 (COL), U1.6 (GPIO4)
COL_11: LFT1.1 (COL), MX42.1 (COL), MX43.1 (COL), MX44.1 (COL), MX45.1 (COL), U1.7 (GPIO5)
COL_12: DWN1.1 (COL), ENT1.1 (COL), MX46.1 (COL), MX47.1 (COL), MX48.1 (COL), U1.9 (GPIO6)
COL_13: BKSP1.1 (COL), DEL1.1 (COL), RHT1.1 (COL), SW1.C, U1.10 (GPIO7), UP1.1 (COL)
DT: SW1.B, U1.2 (GPIO1)
GND: SW1.S2, U1.3 (GND)
unnamed: ALT1.2 (ROW), D15.1 (K)
unnamed: ALT2.2 (ROW), D45.1 (K)
unnamed: BKSP1.2 (ROW), D61.1 (K)
unnamed: CAP1.2 (ROW), D3.1 (K)
unnamed: CTRL1.2 (ROW), D5.1 (K)
unnamed: D1.1 (K), MX1.2 (ROW)
unnamed: D2.1 (K), TAB1.2 (ROW)
unnamed: D4.1 (K), SHFT1.2 (ROW)
unnamed: D6.1 (K), MX2.2 (ROW)
unnamed: D7.1 (K), MX3.2 (ROW)
unnamed: D8.1 (K), MX4.2 (ROW)
unnamed: D9.1 (K), MX5.2 (ROW)
unnamed: D10.1 (K), SUP1.2 (ROW)
unnamed: D11.1 (K), MX6.2 (ROW)
unnamed: D12.1 (K), MX7.2 (ROW)
unnamed: D13.1 (K), MX8.2 (ROW)
unnamed: D14.1 (K), MX9.2 (ROW)
unnamed: D16.1 (K), MX10.2 (ROW)
unnamed: D17.1 (K), MX11.2 (ROW)
unnamed: D18.1 (K), MX12.2 (ROW)
unnamed: D19.1 (K), MX13.2 (ROW)
unnamed: D20.1 (K), MX14.2 (ROW)
unnamed: D21.1 (K), MX15.2 (ROW)
unnamed: D22.1 (K), MX16.2 (ROW)
unnamed: D23.1 (K), MX17.2 (ROW)
unnamed: D24.1 (K), MX18.2 (ROW)
unnamed: D25.1 (K), MX19.2 (ROW)
unnamed: D26.1 (K), MX20.2 (ROW)
unnamed: D27.1 (K), MX21.2 (ROW)
unnamed: D28.1 (K), MX22.2 (ROW)
unnamed: D29.1 (K), MX23.2 (ROW)
unnamed: D30.1 (K), MX24.2 (ROW)
unnamed: D31.1 (K), MX25.2 (ROW)
unnamed: D32.1 (K), SPC1.2 (ROW)
unnamed: D33.1 (K), MX26.2 (ROW)
unnamed: D34.1 (K), MX27.2 (ROW)
unnamed: D35.1 (K), MX28.2 (ROW)
unnamed: D36.1 (K), MX29.2 (ROW)
unnamed: D37.1 (K), MX30.2 (ROW)
unnamed: D38.1 (K), MX31.2 (ROW)
unnamed: D39.1 (K), MX32.2 (ROW)
unnamed: D40.1 (K), MX33.2 (ROW)
unnamed: D41.1 (K), MX34.2 (ROW)
unnamed: D42.1 (K), MX35.2 (ROW)
unnamed: D43.1 (K), MX36.2 (ROW)
unnamed: D44.1 (K), MX37.2 (ROW)
unnamed: D46.1 (K), MX38.2 (ROW)
unnamed: D47.1 (K), MX39.2 (ROW)
unnamed: D48.1 (K), MX40.2 (ROW)
unnamed: D49.1 (K), MX41.2 (ROW)
unnamed: D50.1 (K), FNC1.2 (ROW)
unnamed: D51.1 (K), MX42.2 (ROW)
unnamed: D52.1 (K), MX43.2 (ROW)
unnamed: D53.1 (K), MX44.2 (ROW)
unnamed: D54.1 (K), MX45.2 (ROW)
unnamed: D55.1 (K), LFT1.2 (ROW)
unnamed: D56.1 (K), MX46.2 (ROW)
unnamed: D57.1 (K), MX47.2 (ROW)
unnamed: D58.1 (K), ENT1.2 (ROW)
unnamed: D59.1 (K), MX48.2 (ROW)
unnamed: D60.1 (K), DWN1.2 (ROW)
unnamed: D62.1 (K), DEL1.2 (ROW)
unnamed: D63.1 (K), UP1.2 (ROW)
unnamed: D64.1 (K), RHT1.2 (ROW)
unnamed: D65.1 (K), SW1.S1
ROW_0: D1.2 (A), D6.2 (A), D11.2 (A), D16.2 (A), D20.2 (A), D24.2 (A), D28.2 (A), D33.2 (A), D37.2 (A), D41.2 (A), D46.2 (A), D51.2 (A), D56.2 (A), D61.2 (A), U1.26 (GPIO20)
ROW_1: D2.2 (A), D7.2 (A), D12.2 (A), D17.2 (A), D21.2 (A), D25.2 (A), D29.2 (A), D34.2 (A), D38.2 (A), D42.2 (A), D47.2 (A), D52.2 (A), D57.2 (A), D65.2 (A), U1.25 (GPIO19)
ROW_2: D3.2 (A), D8.2 (A), D13.2 (A), D18.2 (A), D22.2 (A), D26.2 (A), D30.2 (A), D35.2 (A), D39.2 (A), D43.2 (A), D48.2 (A), D53.2 (A), D58.2 (A), D62.2 (A), U1.24 (GPIO18)
ROW_3: D4.2 (A), D9.2 (A), D14.2 (A), D19.2 (A), D23.2 (A), D27.2 (A), D31.2 (A), D36.2 (A), D40.2 (A), D44.2 (A), D49.2 (A), D54.2 (A), D59.2 (A), D63.2 (A), U1.22 (GPIO17)
ROW_4: D5.2 (A), D10.2 (A), D15.2 (A), D32.2 (A), D45.2 (A), D50.2 (A), D55.2 (A), D60.2 (A), D64.2 (A), U1.21 (GPIO16)

Board: 2 copper layers, 303.5 x 97.8 mm, 131 parts (66 on the bottom side), 87 nets.

## Code that names these connections

File keyboard-code/rust-code/src/main.rs (part):

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    // ? GPIO pin and variable set up
    // rows
    let row_pins: &[&dyn InputPin<Error = core::convert::Infallible>] = &[
        &pins.gpio20.into_pull_up_input(),
        &pins.gpio19.into_pull_up_input(),
        &pins.gpio18.into_pull_up_input(),
        &pins.gpio17.into_pull_up_input(),
        &pins.gpio16.into_pull_up_input(),
    ];

    // cols
    // so we can cycle through each column to check rows, first turn them into dynpins then put in array
    let col0: DynPin = pins.gpio13.into();
    let col1: DynPin = pins.gpio14.into();
    let col2: DynPin = pins.gpio15.into();
    let col3: DynPin = pins.gpio12.into();
    let col4: DynPin = pins.gpio11.into();
    let col5: DynPin = pins.gpio10.into();
    let col6: DynPin = pins.gpio9.into();
    let col7: DynPin = pins.gpio8.into();
    let col8: DynPin = pins.gpio2.into();
    let col9: DynPin = pins.gpio3.into();
    let col10: DynPin = pins.gpio4.into();
    let col11: DynPin = pins.gpio5.into();
    let col12: DynPin = pins.gpio6.into();
    let col13: DynPin = pins.gpio7.into();

    let mut col_pins = [
        col0, col1, col2, col3, col4, col5, col6, col7, col8, col9, col10, col11, col12, col13,
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    }

    // rotary encoder
    let rot_a = &pins.gpio0.into_pull_up_input();
    let rot_b = &pins.gpio1.into_pull_up_input();
    let mut rot_a_last_state = rot_a.is_low().unwrap();
    let mut rot_was_pressed = false;
    let mut rot_can_push = true;
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
File keyboard-code/code/src/main.c:

// Aleksas Girenas 15/10/2022
// OrionsHands Firmware for rp pico w

#include "hardware/gpio.h"
#include "pico/stdlib.h"
#include "bt_hid.c"
#include "pico/cyw43_arch.h"
#include "pico/multicore.h"

/*
// keyboard rotary encoder inputs
#define CLK 0
#define DT 1
*/

// for debounce
#define CONFIRMED_PRESS 5
// bluetooth reporting rate
#define REPORT_DELAY_MS 1

// ?keymaps
const uint8_t keymap[5][14] =
{
    {0x29,0x1E,0x1F,0x20,0x21,0x22,0x23,0x24,0x25,0x26,0x27,0x2D,0x2E,0x2A},
    {0x2B,0x14,0x1A,0x08,0X15,0X17,0X1C,0X18,0X0C,0X12,0X13,0X2F,0X30,0X48},
    {0x39,0X04,0X16,0X07,0X09,0X0A,0X0B,0X0D,0X0E,0X0F,0X33,0X34,0X28,0X4C},
    {0xE1,0X31,0X1D,0X1B,0X06,0X19,0X05,0X11,0X10,0X36,0X37,0X38,0X32,0X52},
    {0xE0,0XE3,0XE2,0X00,0X00,0X00,0X2C,0X00,0X00,0XE6,0x00,0X50,0X51,0X4F}
};
const uint8_t fn_keymap[5][14] =
{
    {0x00,0X3A,0X3B,0X3C,0X3D,0X3E,0X3F,0X40,0X41,0X42,0X43,0X44,0X45,0x00},
    {0x2B,0x14,0x1A,0x08,0X15,0X17,0X1C,0X18,0X0C,0X12,0X13,0X2F,0X30,0X48},
    {0x39,0X04,0X16,0X07,0X09,0X0A,0X0B,0X0D,0X0E,0X0F,0X33,0X34,0X28,0X4C},
    {0xE1,0X31,0X1D,0X1B,0X06,0X19,0X05,0X11,0X10,0X36,0X37,0X38,0X32,0X52},
    {0xE0,0XE3,0XE2,0X00,0X00,0X00,0X2C,0X00,0X00,0XE6,0x00,0X50,0X51,0X4F}
};

// define key outputs i.e. pressed or released
uint8_t pressed_keys[5][14] = {0};
// define key debounce counter array
int8_t debounce_keys[5][14] = {0};
// gpio pin nums of keyboard columns starting from COL_0, COL_1, ...
uint8_t cols[14] = {13,14,15,12,11,10,9,8,2,3,4,5,6,7};
// gpio pin nums of keyboard rows starting from ROW_0, ROW_2,...
uint8_t rows[5] = {20,19,18,17,16};

// ?timers
bool timer_fired = false;
int64_t report_alarm_callback(alarm_id_t id, void *user_data){
    // alarm is completed 
    timer_fired = true;
    return 0;
}

void scan_keys(){
    //? Scan all keys to assign which are pressed/released to pressed_keys
    for(int col = 0; col < 14; col++){
        // send signal from this column
        gpio_set_dir(cols[col], true);
        gpio_put(cols[col], 0);
        for(int row = 0; row < 5; row++){
            // read row row: if it is 0 and the debounce on the key exceeds FLIP, then col,row is pressed
            if(gpio_get(rows[row]) == 0){
                if(debounce_keys[row][col] > CONFIRMED_PRESS){
                    // key has been confirmed to be pressed
                    pressed_keys[row][col] = 1;
                    debounce_keys[row][col] = 0;
                }
                else{
                    // increment debounce state
                    debounce_keys[row][col] ++;
                }
            }
            else {
                if(debounce_keys[row][col] < -CONFIRMED_PRESS){
                    // key has been confirmed to be released
                    pressed_keys[row][col] = 0;
                    debounce_keys[row][col] = 0;
                }
                else{
                    // decrement debounce state
                    debounce_keys[row][col] --;
                }
            }
        }
        // turn off signal from this column
        gpio_set_dir(cols[col], false);
    }
}

void core1_main(){
    //? testing
    while(true){
        cyw43_arch_gpio_put(CYW43_WL_GPIO_LED_PIN, 1);
        sleep_ms(1000);
        cyw43_arch_gpio_put(CYW43_WL_GPIO_LED_PIN, 0);
        sleep_ms(1000);
    }
}

int main()
{
    //? Initialise
    stdio_init_all();
    if (cyw43_arch_init())
    {
        // failed to init cyw43
        return -1;
    }

    bt_init();
    multicore_launch_core1(core1_main);
    
    //? set up report alarm
    add_alarm_in_ms(REPORT_DELAY_MS, report_alarm_callback, NULL, false);

    //? init gpio pins and set directions
    for(int col = 0; col < 14; col++){
        gpio_init(cols[col]);
        gpio_set_dir(cols[col], false);
        gpio_pull_up(cols[col]);
    }
    for(int row = 0; row < 5; row++){
        gpio_init(rows[row]);
        gpio_set_dir(rows[row], false);
        gpio_pull_up(rows[row]);
    }

    while (true)
    {   
        scan_keys();

        if(timer_fired){
            //? queue the chars that are currently pressed and ready the report
            for(int col = 0; col < 14; col++){
                for(int row = 0; row < 5; row++){
                    if(pressed_keys[row][col] == 1){
                        if(pressed_keys[4][10]){
                            queue_character(fn_keymap[row][col]);
                        }
                        else{
                            queue_character(keymap[row][col]);
                        }
                    }
                }
            }
            // queue_character(0x09);
            report_ready();
            //? add a new alarm
            add_alarm_in_ms(REPORT_DELAY_MS, report_alarm_callback, NULL, false);
        }
    }

    return 0;
}

## Commit log

2022-10-04 added keyboard project files
2022-10-04 added submodules for keyboard footprints
2022-10-04 added project specific footprints to project
2022-10-08 schematic started
    + also added Raspberry Pi Pico schematics and footprints
2022-10-08 labelling rows/columns/connections in schematic
2022-10-08 removed column from schematic
    - making it more efficient use of GPIO pins
2022-10-08 Revert "removed column from schematic"
    This reverts commit 2b4230f3693d24e53e3d9f57aeab1cc1c25adc82.
2022-10-08 Revert "Revert "removed column from schematic""
    This reverts commit c3aeac9788460b2a484cb539753cd628e228612a.
2022-10-08 assigned footprints and fixed naming
2022-10-08 added footprints to pcb editor
2022-10-08 initial pcb layout
2022-10-08 diodes and mcu flipped to other side of board
2022-10-08 no changes
2022-10-08 added edge cuts
2022-10-08 fixed edge cut where it was going through holes
2022-10-09 fixed error in schematic and moved rotary encoder up
2022-10-09 routed key matric with tracks
    + rows and rotary encoder connected to GPIO pins
    * still need to connect remaining columns
2022-10-09 fixed track on pcb
2022-10-09 added column GPIO tracks - pcb completed
2022-10-09 added screenshots
    + 3D view front and back and PCB view
2022-10-09 DRC and Parity check run
    + corrected errors fixing - silkscreens and unconnected wires
2022-10-10 pcb modifications
    + added footprint cutout for RP Pico so pads on RP Pico can be accessed
    + rerouted some tracks and cleaned up
    + DRC checked with parity
2022-10-10 silkscreen name added and gerbers generated
2022-10-10 locked parts in pcb
2022-10-10 updated pcb with silkscreen and new gerber files
    + silkscreen required for printing with jlcpcb
2022-10-11 added sample images of pcb
2022-10-13 added cpp keyboard-code
    + includes cmake files and config
2022-10-13 cleaned up directory
    + misconfigured so restarting
2022-10-13 cleaned up directory
    - misconfigured so restarting
2022-10-14 fixed cmake and configs
    + running main.c worked and the project is properly configured
2022-10-14 added -D_CRT_SECURE_NO_WARNINGS to cmakelists
    + preprocessor def silences warnings
2022-10-14 made cmakelists cleaner
2022-10-14 testing config for code
2022-10-14 added screenshots of layouts and pcb
2022-10-15 updated cmakelists and added to main.c
    + mostly just cleaning up and testing things out
2022-10-15 added possible options for build in cmakelists
    + will probably not use them unless debugging
2022-10-15 cleaned up repo
2022-10-15 added keyboard matrix logic and debounce
    * need to relate key_out to key values now and send through HID usb
2022-10-15 added testing using LED to blink on press/release
2022-10-16 changed test to serial usb output
2022-10-16 bug fix - need to set low to read
2022-10-16 simplified logic and added faster debounce iter
2022-10-16 bugfix on confirming if debounce passed
    + also corrected spelling in comments and newline for printf
2022-10-16 testing other debounce algorithms
    + 2* faster decrement than increment on debounce state
2022-10-16 bugfix - removed decrement 2* as fast on debounce
    - decrement faster caused erroneous reporting of clicks
    + using even increment and decrement on debounce
    + testing ideal thresholds
2022-10-16 fixed possible bug using a flip-flop for debounce
2022-10-16 buf-fix for debounce logic and clean up
    + need to check again key_out state for debounce
    +better comments and defines
2022-10-16 improved debounce logic and better comments
    + trimming down cases
2022-10-17 commented out uart reporting of debounce state
2022-10-18 added keymaps and testing statements added
2022-10-18 added use of fn key logic and cleanup
    + not the most elegant solution but works
2022-10-21 clean rebuild
2022-10-21 no changes
    + only cache
2022-10-21 removed unused func
2022-10-22 added rust-code - lets try code in rust !
2022-10-23 clean up and added python version of code
2022-10-23 simple blinking example in rust made
    + added configs and key packages
2022-10-23 added gitignore and updated Cargo.toml
2022-10-23 added pi pico specific configs and clean up
2022-10-23 removed unused crates and includes
2022-10-24 cleaned up configs
    - removed commented options
2022-10-24 added usb hid to rust code
    + struggled to implement a loop over gpio pins....
    * still need to learn rust fully
2022-10-25 cleaned up src
2022-10-25 started adding logic for keyboard
2022-10-25 added core implementation of keyboard logic
    + added col/row loops and can report to usb
    + testing with 2 keys
2022-10-25 cleaning up directories and unused code
2022-10-25 better comments added
2022-10-26 added rest of key codes
    + still need to add fnc key layer
    * still need to check keycodes for certain keys or add to them
    * might need to fork and add the rest from usbd-human-interface-device
2022-10-26 better notes/comments
2022-10-27 added better logic for polling keys and cleaned up
2022-10-27 added DynPins to loop through col_pins array
    + much easier to manage
    - removed unused code
2022-10-27 bug fix, included index for col_pins pull up input
2022-10-27 bug fix polling keys loop
    + was not iterating on last column
2022-10-27 added while loop to wait till last state settles
    +until the pull_up_input state of previous pin settles (to fix bug)
2022-10-27 removed while loop until settling
    - was running infinite
2022-10-29 added fn key layer keymap
    + also some comments and serial_number of device using date+time
2022-10-29 added todo comments and cleaned up comments
2022-11-02 added rotary encoder logic
2022-11-06 bug fix - fn key is at 4,10 not 4,11
2022-11-06 added to do comment
2022-11-06 added consumer control logic
    + consumer controls for media keys
    + some comment clean ups
2022-11-06 bug fix - for consumer polling
    * only one index for getting codes
2022-11-07 clean up comments and incremented serial num
2022-11-07 edited jpg - rotary encoder schematic is wrong
2022-11-08 added debounce logic
2022-11-08 improved debounce comment
2022-11-08 added some comments on debounce iterations
2022-11-08 removed unused commented code
    - the commented code was for the example key polling method
2022-11-08 comment clean up
2022-11-08 added to bluetooth todo comment
2022-11-13 simplified rotary encoder logic
2022-11-14 completed rotary encoder logic and spot checks
    + play/pause on release implemented
    - removed unused
2022-11-14 added extra consumer controls for rot encoder
    + next/prev track controls added when pushed and rotated
    + also cleaned up comments
2022-11-14 formatting code
    + autoformatted
2022-11-14 increased consumer polling rate
    + plenty of headroom for lower polling rate countdown
    + and cleaned up comments
2022-11-15 better comments and increased serial num
2022-11-19 updated usb_dev func and added grave key
    + incremented serial num
    + set manufacturer to Allorx
    + added grave key when fn key pressed
2022-11-19 updated key layout image
    + better representing the key layout
2022-11-19 cleaned up and adjusted key layout
    * might use this?
2022-11-19 corrected layout
    * might use this?
2022-11-19 altered key layout - some keys have been changed
    + reflects the KeyLayout.png
2022-11-19 improved layout png and added comments
2022-11-23 added todo comment
2022-11-25 added PID code for this project
    + based on this https://github.com/pidcodes/pidcodes.github.com/pull/785
    + comments for future component features
2023-01-14 cleaned up comments
2023-01-20 added and corrected to proper workspace settings
    + using workspace rather than user/global
2023-01-20 added comments to workspace settings
2023-01-21 multicore set up and clean up comments
    + so we can use core1 for display without affecting core0 for keyboard
2023-01-22 i2c and display set up on core1
    + still needs testing
    + also improvements to core1 spawn and set up
2023-01-23 moved keys and consumer to separate files
    + cleaner main.rs and easier to adjust values
2023-01-23 improved core1_task fn and clean up
    + mostly just cleaning up and making things neater
    + improvements to core1_task fn are unknown - still not quite working
    + led blink test added in core1_task fn
2023-01-23 incremented usb hid serial num
    + as new build
2023-01-23 removed probe-run as not using
2023-01-23 cleaned up dependencies/linker + using panic-halt
2023-01-24 implemented proper exception frame handling
    + i2c display working!
2023-01-24 better comments
2023-01-25 display animation implemented
    + cleaner implementation
    - removed test led
2023-01-26 turn off display after inactivity period
    + using spinlock writing DISPLAY_ON on core1/reading on core2
2023-01-26 changed messaging to use fifo instead
    + fifo more efficient/faster as no spinlocks on threads
    + also looks cleaner/simpler/easier to understand/maintain
2023-01-26 put fifo display messages in const u32 values
    + better clarity and easier to modify
2023-01-26 increased display off time
2023-01-26 cleaned up variables and clearer variable names
2023-01-27 capslock fifo to i2c display implemented
    + get capslock state from usb
    + send state fifo to core1
    + draw capslock animation to display
2023-01-28 added text for caps lock
    + reversed rotation so text renders properly
    * coordinate system is reversed for primitives vs text
2023-01-28 made caps lock symbol rounded for display
2023-01-28 increased font size for display
2023-01-28 adjust text and caps positions/animation
2023-01-29 added commented host->device message idea
    + using led report flicker to send binary data
    + commented as just idea
2023-01-29 removed commented ideas
2023-07-06 added c files back
2023-07-06 reset gitmodules
2023-07-06 updated gitmodules
2023-07-06 removed pico-sdk
2023-07-06 fixed submodule pico sdk
2023-07-06 updated pico sdk
2023-07-07 added gitignore
2023-07-07 remove build folder + added to gitignore
2023-07-07 disable usb io
2023-07-14 testing bluetooth hid keyboard with btstack
    + connects and types buffer
    + using hid keyboard demo from btstack 6kro
    - commented out previous logic
2023-08-21 exclude .cache
2023-11-14 corrected rotary encoder schematic + pcb
    + needed to be rotated
    + removed backups
2023-11-14 corrected images after rotarry encoder correction
2023-11-14 Update to remove rotary encoder issue
    - was solved by rotary encoder fix
2023-11-19 setting up pico w with bluetooth
    + still has some issues but wip
2023-11-19 better comments about scanning rows
2023-11-19 fixed report delay + erroneous comment
2023-11-20 Update README.md
    + corrections
2023-11-20 reset latency/timeout
2023-11-20 firmware version of schematics
    + reversed diodes
2023-11-20 remove empty project file
2023-11-20 details about pcb project files
2023-11-22 corrected version + cleaned up images
    + adding images to separate folder
2023-12-02 made portable + clean up
2024-09-27 added link to full repo for the rp pico kicad library
    + link is already in the root dir but the library was copied separately so adding the link here as well for clarity
